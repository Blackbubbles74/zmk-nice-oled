## boards/shields/nice_oled/Kconfig.shield
```kconfig
config SHIELD_NICE_OLED
    def_bool $(shields_list_contains,nice_oled)
NICE_OLED_POKEMON_ANIMATION=y
```
